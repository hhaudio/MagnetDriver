# Repository hhaudio/MagnetDriver

## KiCad design MagnetDriver.kicad_pcb

Parts:
C1, C2, C4, C5, C11: 0.1uf; C_Disc_D3.0mm_W2.0mm_P2.50mm
C3, C6: 470pf; C_Disc_D3.0mm_W2.0mm_P2.50mm
C7, C8, C9: 10uf; C_Disc_D5.1mm_W3.2mm_P5.00mm
C10: CP; CP_Radial_D10.0mm_P5.00mm
D1, D4: 1N914; DO-35-P5mm
D2, D5, D7: 1N4001; D_DO-41_SOD81_P7.62mm_Horizontal
D3, D6, D8: LED; LED_D5.0mm
H1, H2, H3, H4: MountingHole; M3_MOUNT_KEEPOUT
J1: MAGNET1; Phoenix_Stacked_Marking2
J2: MAGNET2; Phoenix_Stacked_Marking2
J3: INPUT_JACK; Tayda_SwitchedStereoJack-PJ-307
J4: PWR_IN; Phoenix_Stacked_Marking2
Q1, Q4: 2N3904; TO-92_Inline
Q2, Q5: TIP122; TO-220_BigHeatsink
Q3, Q6: TIP32A; TO-220-3_Horizontal_TabDown
R1, R10: 1M; R_THT_P7.62
R2, R11: 1k; R_THT_P7.62
R3, R4, R12, R13: 100k; R_THT_P7.62
R5, R6, R14, R15: 10k; R_THT_P7.62
R7, R8, R16, R17: 100R; R_THT_P7.62
R9, R18, R19: 220; R_THT_P7.62
RV1, RV3: A1M; PTV09_PT6_Stacked
RV2, RV4: B10K; PTV09_PT6_Stacked
U1: LM324; DIP-14_W7.62mm_Socket
U2: TEENSY_3.6_MINIMAL; TEENSY_3.5_3.6_MINIMAL
U3: LM7805_TO220; TO-220-3_Horizontal_TabDown

Connections:
GND: C7.1, C8.2, C9.2, C10.2, C11.1, D1.2 (A), D2.2 (A), D3.1 (K), D4.2 (A), D5.2 (A), D6.1 (K), D7.2 (A), D8.1 (K), J1.1, J2.1, J3.S, J4.1, Q3.2 (C), Q6.2 (C), R1.2, R4.2, R5.2, R6.2, R10.2, R13.2, R14.2, R15.2, RV2.1, RV4.1, U1.3 (+), U1.5 (+), U1.11 (V-), U2.1 (GND), U2.34 (GND), U3.2; also elsewhere on the board
IN_L: C1.2, J3.T, R1.1
IN_R: C4.2, J3.R, R10.1
unnamed: C1.1, R2.2
unnamed: C2.1, R6.1, R7.2
unnamed: C2.2, Q1.1 (E), R5.1
unnamed: C3.1, RV1.3, U1.1, U1.12 (+)
unnamed: C3.2, R8.1, RV1.1, RV1.2, U1.2 (-)
unnamed: C4.1, R11.2
unnamed: C5.1, R15.1, R16.2
unnamed: C5.2, Q4.1 (E), R14.1
unnamed: C6.1, RV3.3, U1.7, U1.10 (+)
unnamed: C6.2, R17.1, RV3.1, RV3.2, U1.6 (-)
unnamed: D1.1 (K), R7.1, R8.2
unnamed: D2.1 (K), J1.2, Q2.3 (E), Q3.3 (E), R9.1
unnamed: D3.2 (A), R9.2
unnamed: D4.1 (K), R16.1, R17.2
unnamed: D5.1 (K), J2.2, Q5.3 (E), Q6.3 (E), R18.1
unnamed: D6.2 (A), R18.2
unnamed: D8.2 (A), R19.2
unnamed: Q1.2 (B), R2.1, R3.1, R4.1
unnamed: Q2.1 (B), Q3.1 (B), RV2.2
unnamed: Q4.2 (B), R11.1, R12.1, R13.1
unnamed: Q5.1 (B), Q6.1 (B), RV4.2
unnamed 26: U2.44 (22_A8_PWM_Touch); also elsewhere on the board
unnamed 27: U2.45 (23_A9_PWM_Touch); also elsewhere on the board
unnamed: RV2.3, U1.13 (-), U1.14
unnamed: RV4.3, U1.8, U1.9 (-)
TEENSY_L: J3.TN, U2.32 (A21_DAC0)
TEENSY_R: J3.RN, U2.33 (A22_DAC1)
VDC: C7.2, C9.1, C10.1, C11.2, D7.1 (K), J4.2, Q1.3 (C), Q2.2 (C), Q4.3 (C), Q5.2 (C), R3.2, R12.2, R19.1, U1.4 (V+), U3.1

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
Board: 2 copper layers, 100.0 x 100.0 mm, 67 parts (1 on the bottom side), 36 nets.

Other parts of the board:
D9: LED; LED_D5.0mm
HH_LOGO_17.5x8.75mm: HH_LOGO_17.5x8.75mm
HH_LOGO_32x16: HH_LOGO_32x16
Q7: 2N3904; TO-92_Inline
R20: 220; R_THT_P7.62
R21: 1k; R_THT_P7.62
R22: 100k; R_THT_P7.62
SW1: SW_SPDT; Tayda_Slide_SPDT

Their connections:
GND: D9.1, Q7.1, R22.1; also elsewhere on the board
unnamed: D9.2, R20.1
unnamed: Q7.2, R21.1, R22.2
unnamed 26: Q7.3; also elsewhere on the board
unnamed 27: R20.2; also elsewhere on the board
unnamed: R21.2, SW1.1

File MagnetDriver_BOM.csv:

Comment,Designator,Footprint,LCSC
"0.1uf","C1,C2,C4,C5,C11","Capacitor_THT:C_Disc_D3.0mm_W2.0mm_P2.50mm","C1620173"
"CP","C10","Capacitor_THT:CP_Radial_D10.0mm_P5.00mm",""
"470pf","C3,C6","Capacitor_THT:C_Disc_D3.0mm_W2.0mm_P2.50mm","C1620141"
"DNP","C7,C8","Capacitor_THT:C_Disc_D5.1mm_W3.2mm_P5.00mm",""
"10uf","C9","Capacitor_THT:C_Disc_D5.1mm_W3.2mm_P5.00mm","C2761740"
"1N914","D1,D4","HammerheadAudio:DO-35-P5mm","C258180"
"LED","D3,D6,D8","LED_THT:LED_D5.0mm","C2895493"
"1N4001","D2,D5,D7","Diode_THT:D_DO-41_SOD81_P7.62mm_Horizontal","C2456"
"DNP","D9","LED_THT:LED_D5.0mm","C2895493"
"MountingHole","H1,H2,H3,H4","HammerheadAudio:M3_MOUNT_KEEPOUT",""
"MAGNET1","J1","HammerheadAudio:Phoenix_Stacked_Marking2","C430324"
"MAGNET2","J2","HammerheadAudio:Phoenix_Stacked_Marking2","C430324"
"INPUT_JACK","J3","HammerheadAudio:Tayda_SwitchedStereoJack-PJ-307","C16684"
"PWR_IN","J4","HammerheadAudio:Phoenix_Stacked_Marking2","C430324"
"2N3904","Q1,Q4","Package_TO_SOT_THT:TO-92_Inline","C2874602"
"TIP122","Q2,Q5","HammerheadAudio:TO-220_BigHeatsink","C16283"
"TIP32A","Q3,Q6","Package_TO_SOT_THT:TO-220-3_Horizontal_TabDown","C2927632"
"DNP","Q7","Package_TO_SOT_THT:TO-92_Inline","C2874602"
"1M","R1,R10","HammerheadAudio:R_THT_P7.62",""
"1k","R2,R9,R11,R18,R19","HammerheadAudio:R_THT_P7.62","C2894541"
"DNP","R20,R21,R22","HammerheadAudio:R_THT_P7.62",""
"100k","R3,R4,R12,R13","HammerheadAudio:R_THT_P7.62","C714036"
"10k","R5,R6,R14,R15","HammerheadAudio:R_THT_P7.62","C172967"
"100R","R7,R8,R16,R17","HammerheadAudio:R_THT_P7.62","C57438"
"A1M","RV1,RV3","HammerheadAudio:PTV09_PT6_Stacked","C5205027"
"B10K","RV2,RV4","HammerheadAudio:PTV09_PT6_Stacked","C5205027"
"DNP","SW1","HammerheadAudio:Tayda_Slide_SPDT",""
"LM324","U1","Package_DIP:DIP-14_W7.62mm_Socket","C132508"
"TEENSY_3.6_MINIMAL","U2","MeowWolf_Templates:TEENSY_3.5_3.6_MINIMAL",""
"R-78E5.0-0.5","U3","Converter_DCDC:Converter_DCDC_RECOM_R-78E-0.5_THT",""

## Commit log

2021-01-10 made schematic
2021-01-10 checked schematic + footprints
2021-01-10 arranging components
2021-01-10 placed components
2021-01-11 silkscreen stuff
2021-01-11 finished first layout
2021-01-11 added render
2021-01-11 testing adding teesny switch
2025-04-30 backup before layout changes
